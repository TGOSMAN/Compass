# Keil uVision project gpio_led_output.uvprojx, settings and files
target gpio_led_output debug (6190000::V6.19::ARMCLANG)
  device: LPC804M101JDH24 NXP
  pack: NXP.LPC804_DFP.18.0.0
  cpu: IRAM(0x10000fe0,0x20) IRAM2(0x10000000,0x0fe0) IROM(0x00007f80,0x80) IROM2(0x00000000,0x7f80) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: gpio_led_output.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 wLevel=3
  c define: DEBUG, CPU_LPC804, CPU_LPC804M101JDH24, MCUXPRESSO_SDK
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..
  asm define: DEBUG,KEIL, DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x7f80 size 0x80
  memory RVCT5: ROM 0x0 size 0x7f80
  memory RVCT9: RAM 0x10000fe0 size 0x20
  memory RVCT10: RAM 0x10000000 size 0xfe0
  scatter file: LPC804_flash.scf
  link misc: --remove --keep=*(.crp) --entry=Reset_Handler --diag_suppress 6314
  group source
    ../: Layer1.h Layer1.c Layer2.c Layer2.h main.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
target gpio_led_output release (6190000::V6.19::ARMCLANG)
  device: LPC804M101JDH24 NXP
  pack: NXP.LPC804_DFP.18.0.0
  cpu: CPUTYPE("Cortex-M0+")
  output: gpio_led_output.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 wLevel=3
  c define: NDEBUG, CPU_LPC804, CPU_LPC804M101JDH24, MCUXPRESSO_SDK
  c misc: as above
  c include: ..
  asm define: CPU_LPC845M301, NDEBUG, KEIL, NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  scatter file: LPC804_flash.scf
  link misc: as above
software components: CMSIS:CORE 5.5.0, Device:CMSIS:LPC804_header 1.0.0, Device:CMSIS:LPC804_system 1.0.0, Device:SDK Drivers:clock 2.3.1, Device:SDK Drivers:common 2.4.0, Device:SDK Drivers:gpio 2.1.7, Device:SDK Drivers:iocon 2.0.2, Device:SDK Drivers:miniusart_adapter 1.0.0, Device:SDK Drivers:power 2.0.0, Device:SDK Drivers:reset 2.1.2, Device:SDK Drivers:rom_api 2.0.1, Device:SDK Drivers:swm 2.1.2, Device:SDK Drivers:swm_connections 2.0.1, Device:SDK Drivers:syscon 2.0.1, Device:SDK Drivers:syscon_connections 2.0.1, Device:SDK Drivers:usart 2.5.0, Device:SDK Utilities:assert_lite 1.0.0, Device:SDK Utilities:debug_console_lite 1.0.0, Device:SDK Utilities:misc_utilities 1.1.1, Device:Startup 1.1.0
